FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://edgeops.cfg"
