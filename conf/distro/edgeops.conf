## conf/distro/edgeops.conf
```bitbake
require conf/distro/poky.conf

DISTRO = "edgeops"
DISTRO_NAME = "EdgeOps Embedded Linux"
DISTRO_VERSION = "1.0"

INIT_MANAGER = "systemd"
```
